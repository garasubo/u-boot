## configs/ls1021atwr_virt_defconfig
```kconfig
CONFIG_SYS_EXTRA_OPTIONS="VIRT_BOOT"
+S:CONFIG_ARM=y
+S:CONFIG_TARGET_LS1021ATWR=y
```
